<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\SICK DT35.ewp</path>
  </project>
  <batchBuild />
</workspace>
